# Keil uVision project YH-μCOS-III.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: YH-μCOS-III
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\User\μC-CPU;..\User\μC-LIB;..\User\μCOS-III\Ports;..\User\μCOS-III\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../../RTOS/User/: app.c
  group Doc
    ../../RTOS/Doc/: readme.txt
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.3
